# IAR project Tsensor.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_MD
  ICCSTM8.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM8L15x_StdPeriph_Driver\inc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Tsensor.srec
  ILINK.IlinkOutputFile: Tsensor.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group STM8L15x_StdPeriph_Driver/src
    ../../../Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_lcd.c stm8l15x_rtc.c stm8l15x_syscfg.c stm8l15x_tim2.c stm8l15x_usart.c stm8l15x_wwdg.c
  group User/src
    ../src/: button.c delay.c i2c_touch_bs8116.c iic.c led.c main.c relay.c remote.c stm8l15x_it.c stm8l_discovery_lcd.c timer.c usart.c
